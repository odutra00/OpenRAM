* Circuit, read from the shapes
.subckt sram_8b_16_1rw_tsmc65N_wordline_driver_array en gnd in_0 in_1 in_10 in_11 in_12 in_13 in_14 in_15 in_2 in_3 in_4 in_5 in_6 in_7 in_8 in_9 vdd wl_0 wl_1 wl_10 wl_11 wl_12 wl_13 wl_14 wl_15 wl_2 wl_3 wl_4 wl_5 wl_6 wl_7 wl_8 wl_9
M1 sram_8b_16_1rw_tsmc65N_wordline_driver_0/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_0 gnd gnd nfet w=0.32u l=0.06u
M2 sram_8b_16_1rw_tsmc65N_wordline_driver_1/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_1 gnd gnd nfet w=0.32u l=0.06u
M3 sram_8b_16_1rw_tsmc65N_wordline_driver_2/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_2 gnd gnd nfet w=0.32u l=0.06u
M4 sram_8b_16_1rw_tsmc65N_wordline_driver_3/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_3 gnd gnd nfet w=0.32u l=0.06u
M5 sram_8b_16_1rw_tsmc65N_wordline_driver_4/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_4 gnd gnd nfet w=0.32u l=0.06u
M6 sram_8b_16_1rw_tsmc65N_wordline_driver_5/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_5 gnd gnd nfet w=0.32u l=0.06u
M7 sram_8b_16_1rw_tsmc65N_wordline_driver_6/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_6 gnd gnd nfet w=0.32u l=0.06u
M8 sram_8b_16_1rw_tsmc65N_wordline_driver_7/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_7 gnd gnd nfet w=0.32u l=0.06u
M9 sram_8b_16_1rw_tsmc65N_wordline_driver_8/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_8 gnd gnd nfet w=0.32u l=0.06u
M10 sram_8b_16_1rw_tsmc65N_wordline_driver_9/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_9 gnd gnd nfet w=0.32u l=0.06u
M11 sram_8b_16_1rw_tsmc65N_wordline_driver_10/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_10 gnd gnd nfet w=0.32u l=0.06u
M12 sram_8b_16_1rw_tsmc65N_wordline_driver_11/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_11 gnd gnd nfet w=0.32u l=0.06u
M13 sram_8b_16_1rw_tsmc65N_wordline_driver_12/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_12 gnd gnd nfet w=0.32u l=0.06u
M14 sram_8b_16_1rw_tsmc65N_wordline_driver_13/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_13 gnd gnd nfet w=0.32u l=0.06u
M15 sram_8b_16_1rw_tsmc65N_wordline_driver_14/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_14 gnd gnd nfet w=0.32u l=0.06u
M16 sram_8b_16_1rw_tsmc65N_wordline_driver_15/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D in_15 gnd gnd nfet w=0.32u l=0.06u
M17 sram_8b_16_1rw_tsmc65N_wordline_driver_0/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_0/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M18 sram_8b_16_1rw_tsmc65N_wordline_driver_1/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_1/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M19 sram_8b_16_1rw_tsmc65N_wordline_driver_2/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_2/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M20 sram_8b_16_1rw_tsmc65N_wordline_driver_3/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_3/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M21 sram_8b_16_1rw_tsmc65N_wordline_driver_4/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_4/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M22 sram_8b_16_1rw_tsmc65N_wordline_driver_5/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_5/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M23 sram_8b_16_1rw_tsmc65N_wordline_driver_6/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_6/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M24 sram_8b_16_1rw_tsmc65N_wordline_driver_7/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_7/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M25 sram_8b_16_1rw_tsmc65N_wordline_driver_8/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_8/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M26 sram_8b_16_1rw_tsmc65N_wordline_driver_9/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_9/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M27 sram_8b_16_1rw_tsmc65N_wordline_driver_10/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_10/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M28 sram_8b_16_1rw_tsmc65N_wordline_driver_11/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_11/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M29 sram_8b_16_1rw_tsmc65N_wordline_driver_12/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_12/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M30 sram_8b_16_1rw_tsmc65N_wordline_driver_13/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_13/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M31 sram_8b_16_1rw_tsmc65N_wordline_driver_14/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_14/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M32 sram_8b_16_1rw_tsmc65N_wordline_driver_15/sram_8b_16_1rw_tsmc65N_pinv_1/A en sram_8b_16_1rw_tsmc65N_wordline_driver_15/sram_8b_16_1rw_tsmc65N_pnand2_0/sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive_2/D gnd nfet w=0.32u l=0.06u
M33 wl_0 sram_8b_16_1rw_tsmc65N_wordline_driver_0/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M34 wl_1 sram_8b_16_1rw_tsmc65N_wordline_driver_1/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M35 wl_2 sram_8b_16_1rw_tsmc65N_wordline_driver_2/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M36 wl_3 sram_8b_16_1rw_tsmc65N_wordline_driver_3/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M37 wl_4 sram_8b_16_1rw_tsmc65N_wordline_driver_4/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M38 wl_5 sram_8b_16_1rw_tsmc65N_wordline_driver_5/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M39 wl_6 sram_8b_16_1rw_tsmc65N_wordline_driver_6/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M40 wl_7 sram_8b_16_1rw_tsmc65N_wordline_driver_7/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M41 wl_8 sram_8b_16_1rw_tsmc65N_wordline_driver_8/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M42 wl_9 sram_8b_16_1rw_tsmc65N_wordline_driver_9/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M43 wl_10 sram_8b_16_1rw_tsmc65N_wordline_driver_10/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M44 wl_11 sram_8b_16_1rw_tsmc65N_wordline_driver_11/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M45 wl_12 sram_8b_16_1rw_tsmc65N_wordline_driver_12/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M46 wl_13 sram_8b_16_1rw_tsmc65N_wordline_driver_13/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M47 wl_14 sram_8b_16_1rw_tsmc65N_wordline_driver_14/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M48 wl_15 sram_8b_16_1rw_tsmc65N_wordline_driver_15/sram_8b_16_1rw_tsmc65N_pinv_1/A gnd gnd nfet w=0.16u l=0.06u
M49 sram_8b_16_1rw_tsmc65N_wordline_driver_0/sram_8b_16_1rw_tsmc65N_pinv_1/A in_0 vdd vdd pfet w=0.24u l=0.06u
M50 sram_8b_16_1rw_tsmc65N_wordline_driver_1/sram_8b_16_1rw_tsmc65N_pinv_1/A in_1 vdd vdd pfet w=0.24u l=0.06u
M51 sram_8b_16_1rw_tsmc65N_wordline_driver_2/sram_8b_16_1rw_tsmc65N_pinv_1/A in_2 vdd vdd pfet w=0.24u l=0.06u
M52 sram_8b_16_1rw_tsmc65N_wordline_driver_3/sram_8b_16_1rw_tsmc65N_pinv_1/A in_3 vdd vdd pfet w=0.24u l=0.06u
M53 sram_8b_16_1rw_tsmc65N_wordline_driver_4/sram_8b_16_1rw_tsmc65N_pinv_1/A in_4 vdd vdd pfet w=0.24u l=0.06u
M54 sram_8b_16_1rw_tsmc65N_wordline_driver_5/sram_8b_16_1rw_tsmc65N_pinv_1/A in_5 vdd vdd pfet w=0.24u l=0.06u
M55 sram_8b_16_1rw_tsmc65N_wordline_driver_6/sram_8b_16_1rw_tsmc65N_pinv_1/A in_6 vdd vdd pfet w=0.24u l=0.06u
M56 sram_8b_16_1rw_tsmc65N_wordline_driver_7/sram_8b_16_1rw_tsmc65N_pinv_1/A in_7 vdd vdd pfet w=0.24u l=0.06u
M57 sram_8b_16_1rw_tsmc65N_wordline_driver_8/sram_8b_16_1rw_tsmc65N_pinv_1/A in_8 vdd vdd pfet w=0.24u l=0.06u
M58 sram_8b_16_1rw_tsmc65N_wordline_driver_9/sram_8b_16_1rw_tsmc65N_pinv_1/A in_9 vdd vdd pfet w=0.24u l=0.06u
M59 sram_8b_16_1rw_tsmc65N_wordline_driver_10/sram_8b_16_1rw_tsmc65N_pinv_1/A in_10 vdd vdd pfet w=0.24u l=0.06u
M60 sram_8b_16_1rw_tsmc65N_wordline_driver_11/sram_8b_16_1rw_tsmc65N_pinv_1/A in_11 vdd vdd pfet w=0.24u l=0.06u
M61 sram_8b_16_1rw_tsmc65N_wordline_driver_12/sram_8b_16_1rw_tsmc65N_pinv_1/A in_12 vdd vdd pfet w=0.24u l=0.06u
M62 sram_8b_16_1rw_tsmc65N_wordline_driver_13/sram_8b_16_1rw_tsmc65N_pinv_1/A in_13 vdd vdd pfet w=0.24u l=0.06u
M63 sram_8b_16_1rw_tsmc65N_wordline_driver_14/sram_8b_16_1rw_tsmc65N_pinv_1/A in_14 vdd vdd pfet w=0.24u l=0.06u
M64 sram_8b_16_1rw_tsmc65N_wordline_driver_15/sram_8b_16_1rw_tsmc65N_pinv_1/A in_15 vdd vdd pfet w=0.24u l=0.06u
M65 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_0/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M66 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_1/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M67 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_2/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M68 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_3/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M69 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_4/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M70 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_5/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M71 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_6/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M72 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_7/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M73 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_8/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M74 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_9/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M75 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_10/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M76 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_11/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M77 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_12/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M78 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_13/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M79 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_14/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M80 vdd en sram_8b_16_1rw_tsmc65N_wordline_driver_15/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd pfet w=0.24u l=0.06u
M81 wl_0 sram_8b_16_1rw_tsmc65N_wordline_driver_0/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M82 wl_1 sram_8b_16_1rw_tsmc65N_wordline_driver_1/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M83 wl_2 sram_8b_16_1rw_tsmc65N_wordline_driver_2/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M84 wl_3 sram_8b_16_1rw_tsmc65N_wordline_driver_3/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M85 wl_4 sram_8b_16_1rw_tsmc65N_wordline_driver_4/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M86 wl_5 sram_8b_16_1rw_tsmc65N_wordline_driver_5/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M87 wl_6 sram_8b_16_1rw_tsmc65N_wordline_driver_6/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M88 wl_7 sram_8b_16_1rw_tsmc65N_wordline_driver_7/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M89 wl_8 sram_8b_16_1rw_tsmc65N_wordline_driver_8/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M90 wl_9 sram_8b_16_1rw_tsmc65N_wordline_driver_9/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M91 wl_10 sram_8b_16_1rw_tsmc65N_wordline_driver_10/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M92 wl_11 sram_8b_16_1rw_tsmc65N_wordline_driver_11/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M93 wl_12 sram_8b_16_1rw_tsmc65N_wordline_driver_12/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M94 wl_13 sram_8b_16_1rw_tsmc65N_wordline_driver_13/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M95 wl_14 sram_8b_16_1rw_tsmc65N_wordline_driver_14/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
M96 wl_15 sram_8b_16_1rw_tsmc65N_wordline_driver_15/sram_8b_16_1rw_tsmc65N_pinv_1/A vdd vdd pfet w=0.24u l=0.06u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
L2_0 = (2, 0)
nwell = (3, 0)
active = (6, 0)
L12_0 = (12, 0)
poly = (17, 0)
pimplant = (25, 0)
nimplant = (26, 0)
contact = (30, 0)
metal1 = (31, 0)
metal2 = (32, 0)
metal3 = (33, 0)
metal4 = (34, 0)
via1 = (51, 0)
via2 = (52, 0)
via3 = (53, 0)
boundary = (108, 0)

sram_8b_16_1rw_tsmc65n_c = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_11')
R(sram_8b_16_1rw_tsmc65n_c, nwell, [(-0.165,-0.15,0.305,0.32)])
R(sram_8b_16_1rw_tsmc65n_c, active, [(0.01,0.025,0.13,0.145)])
R(sram_8b_16_1rw_tsmc65n_c, pimplant, [(-0.04,-0.025,0.18,0.195)])
R(sram_8b_16_1rw_tsmc65n_c, contact, [(0.025,0.04,0.115,0.13)])
R(sram_8b_16_1rw_tsmc65n_c, metal1, [(0,0,0.14,0.17)])
R(sram_8b_16_1rw_tsmc65n_c, boundary, [(-0.165,-0.15,0.305,0.32)])

sram_8b_16_1rw_tsmc65n_p = lib.new_cell('sram_8b_16_1rw_tsmc65N_pmos_m1_w0_242_sm1_dm1')
R(sram_8b_16_1rw_tsmc65n_p, nwell, [(-0.16,-0.16,0.62,0.4)])
R(sram_8b_16_1rw_tsmc65n_p, active, [(0,0,0.46,0.24)])
R(sram_8b_16_1rw_tsmc65n_p, L12_0, [(-0.16,-0.16,0.62,0.4)])
R(sram_8b_16_1rw_tsmc65n_p, poly, [(0.2,-0.14,0.26,0.38), (0.2,-0.14,0.26,0.38)])
R(sram_8b_16_1rw_tsmc65n_p, pimplant, [(-0.05,-0.05,0.51,0.29)])
R(sram_8b_16_1rw_tsmc65n_p, metal1, [(0,0.035,0.14,0.205), (0.32,0.035,0.46,0.205)])
R(sram_8b_16_1rw_tsmc65n_p, boundary, [(-0.16,-0.16,0.62,0.4)])
sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_c, (0,0.035)))
sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_c, (0.32,0.035)))
sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('G', (0.23,0.12), layer=17, texttype=0))
sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('S', (0.07,0.12), layer=31, texttype=0))
sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('D', (0.39,0.12), layer=31, texttype=0))

c_sram_8b_16_1rw_tsmc65n_c = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_10')
R(c_sram_8b_16_1rw_tsmc65n_c, L2_0, [(-0.165,-0.15,0.305,0.32)])
R(c_sram_8b_16_1rw_tsmc65n_c, active, [(0.01,0.025,0.13,0.145)])
R(c_sram_8b_16_1rw_tsmc65n_c, nimplant, [(-0.04,-0.025,0.18,0.195)])
R(c_sram_8b_16_1rw_tsmc65n_c, contact, [(0.025,0.04,0.115,0.13)])
R(c_sram_8b_16_1rw_tsmc65n_c, metal1, [(0,0,0.14,0.17)])
R(c_sram_8b_16_1rw_tsmc65n_c, boundary, [(-0.165,-0.15,0.305,0.32)])

sram_8b_16_1rw_tsmc65n_n = lib.new_cell('sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sm1_dactive')
R(sram_8b_16_1rw_tsmc65n_n, L2_0, [(-0.16,-0.16,0.62,0.48)])
R(sram_8b_16_1rw_tsmc65n_n, active, [(0,0,0.46,0.32), (0.35,0.12,0.43,0.2)])
R(sram_8b_16_1rw_tsmc65n_n, L12_0, [(-0.16,-0.16,0.62,0.48)])
R(sram_8b_16_1rw_tsmc65n_n, poly, [(0.2,-0.14,0.26,0.46), (0.2,-0.14,0.26,0.46)])
R(sram_8b_16_1rw_tsmc65n_n, nimplant, [(-0.05,-0.05,0.51,0.37)])
R(sram_8b_16_1rw_tsmc65n_n, metal1, [(0,0.075,0.14,0.245)])
R(sram_8b_16_1rw_tsmc65n_n, boundary, [(-0.16,-0.16,0.62,0.48)])
sram_8b_16_1rw_tsmc65n_n.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c, (0,0.075)))
sram_8b_16_1rw_tsmc65n_n.add(gdstk.Label('G', (0.23,0.16), layer=17, texttype=0))
sram_8b_16_1rw_tsmc65n_n.add(gdstk.Label('S', (0.07,0.16), layer=31, texttype=0))
sram_8b_16_1rw_tsmc65n_n.add(gdstk.Label('D', (0.39,0.16), layer=6, texttype=0))

c_sram_8b_16_1rw_tsmc65n_n = lib.new_cell('sram_8b_16_1rw_tsmc65N_nmos_m1_w0_320_sactive_dm1')
R(c_sram_8b_16_1rw_tsmc65n_n, L2_0, [(-0.16,-0.16,0.62,0.48)])
R(c_sram_8b_16_1rw_tsmc65n_n, active, [(0,0,0.46,0.32), (0.03,0.12,0.11,0.2)])
R(c_sram_8b_16_1rw_tsmc65n_n, L12_0, [(-0.16,-0.16,0.62,0.48)])
R(c_sram_8b_16_1rw_tsmc65n_n, poly, [(0.2,-0.14,0.26,0.46), (0.2,-0.14,0.26,0.46)])
R(c_sram_8b_16_1rw_tsmc65n_n, nimplant, [(-0.05,-0.05,0.51,0.37)])
R(c_sram_8b_16_1rw_tsmc65n_n, metal1, [(0.32,0.075,0.46,0.245)])
R(c_sram_8b_16_1rw_tsmc65n_n, boundary, [(-0.16,-0.16,0.62,0.48)])
c_sram_8b_16_1rw_tsmc65n_n.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c, (0.32,0.075)))
c_sram_8b_16_1rw_tsmc65n_n.add(gdstk.Label('G', (0.23,0.16), layer=17, texttype=0))
c_sram_8b_16_1rw_tsmc65n_n.add(gdstk.Label('S', (0.07,0.16), layer=6, texttype=0))
c_sram_8b_16_1rw_tsmc65n_n.add(gdstk.Label('D', (0.39,0.16), layer=31, texttype=0))

c_sram_8b_16_1rw_tsmc65n_c_ = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_12')
R(c_sram_8b_16_1rw_tsmc65n_c_, nwell, [(-0.165,-0.15,0.305,0.32)])
R(c_sram_8b_16_1rw_tsmc65n_c_, active, [(0.01,0.025,0.13,0.145)])
R(c_sram_8b_16_1rw_tsmc65n_c_, nimplant, [(-0.04,-0.025,0.18,0.195)])
R(c_sram_8b_16_1rw_tsmc65n_c_, contact, [(0.025,0.04,0.115,0.13)])
R(c_sram_8b_16_1rw_tsmc65n_c_, metal1, [(0,0,0.14,0.17)])
R(c_sram_8b_16_1rw_tsmc65n_c_, boundary, [(-0.165,-0.15,0.305,0.32)])

c_sram_8b_16_1rw_tsmc65n_c__ = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_13')
R(c_sram_8b_16_1rw_tsmc65n_c__, L2_0, [(-0.165,-0.15,0.305,0.32)])
R(c_sram_8b_16_1rw_tsmc65n_c__, active, [(0.01,0.025,0.13,0.145)])
R(c_sram_8b_16_1rw_tsmc65n_c__, pimplant, [(-0.04,-0.025,0.18,0.195)])
R(c_sram_8b_16_1rw_tsmc65n_c__, contact, [(0.025,0.04,0.115,0.13)])
R(c_sram_8b_16_1rw_tsmc65n_c__, metal1, [(0,0,0.14,0.17)])
R(c_sram_8b_16_1rw_tsmc65n_c__, boundary, [(-0.165,-0.15,0.305,0.32)])

c_sram_8b_16_1rw_tsmc65n_c___ = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_14')
R(c_sram_8b_16_1rw_tsmc65n_c___, poly, [(0.03,0.015,0.14,0.125)])
R(c_sram_8b_16_1rw_tsmc65n_c___, contact, [(0.04,0.025,0.13,0.115)])
R(c_sram_8b_16_1rw_tsmc65n_c___, metal1, [(0,0,0.17,0.14)])
R(c_sram_8b_16_1rw_tsmc65n_c___, boundary, [(0,0,0.17,0.14)])

c_sram_8b_16_1rw_tsmc65n_p = lib.new_cell('sram_8b_16_1rw_tsmc65N_pnand2')
R(c_sram_8b_16_1rw_tsmc65n_p, L2_0, [(-0.16,-0.045,1.515,1.135)])
R(c_sram_8b_16_1rw_tsmc65n_p, nwell, [(-0.16,1.135,1.515,2.48)])
R(c_sram_8b_16_1rw_tsmc65n_p, L12_0, [(-0.16,-0.045,1.515,1.135), (-0.16,1.135,1.515,2.48)])
R(c_sram_8b_16_1rw_tsmc65n_p, poly, [(0.36,0.57,0.39,0.68), (0.36,0.66,0.42,1.78), (0.68,0.66,0.74,1.78), (0.68,1.09,0.71,1.2)])
R(c_sram_8b_16_1rw_tsmc65n_p, metal1, [(0,-0.045,1.355,0.045), (0.16,-0.045,0.3,0.275), (1.04,0,1.18,0.26), (0.825,0.445,0.915,0.675), (0.305,0.555,0.475,0.695), (0.825,0.63,0.915,0.72), (0.87,0.63,1.1,0.72), (1.055,0.63,1.145,0.72), (1.055,0.675,1.145,1.795), (0.625,1.075,0.795,1.215), (0.505,1.75,0.595,1.84), (0.55,1.75,1.1,1.84), (1.055,1.75,1.145,1.84), (0.505,1.795,0.595,1.955), (0.16,1.955,0.3,2.405), (0.8,1.955,0.94,2.405), (1.04,2.05,1.18,2.36), (0,2.315,1.355,2.405)])
R(c_sram_8b_16_1rw_tsmc65n_p, boundary, [(0,0,1.355,2.36), (0,0,1.355,2.36)])
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_p, (0.16,1.92)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_p, (0.48,1.92)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_n, (0.16,0.2)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_n, (0.48,0.2)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_, (1.04,1.965)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c__, (1.04,0.175)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c___, (0.305,0.555)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c___, (0.625,1.075)))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('Z', (1.1,1.795), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('gnd', (0.678,0), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('vdd', (0.678,2.36), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('A', (0.39,0.625), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p.add(gdstk.Label('B', (0.71,1.145), layer=31, texttype=0))

c_sram_8b_16_1rw_tsmc65n_p_ = lib.new_cell('sram_8b_16_1rw_tsmc65N_pmos_m1_w0_240_sm1_dm1_da_p')
R(c_sram_8b_16_1rw_tsmc65n_p_, nwell, [(-0.16,-0.16,0.62,0.4)])
R(c_sram_8b_16_1rw_tsmc65n_p_, active, [(0,0,0.46,0.24)])
R(c_sram_8b_16_1rw_tsmc65n_p_, L12_0, [(-0.16,-0.16,0.62,0.4)])
R(c_sram_8b_16_1rw_tsmc65n_p_, poly, [(0.2,-0.14,0.26,0.38), (0.2,-0.14,0.26,0.38)])
R(c_sram_8b_16_1rw_tsmc65n_p_, pimplant, [(-0.05,-0.05,0.51,0.29)])
R(c_sram_8b_16_1rw_tsmc65n_p_, metal1, [(0,0.035,0.14,0.205), (0.32,0.035,0.46,0.205)])
R(c_sram_8b_16_1rw_tsmc65n_p_, boundary, [(-0.16,-0.16,0.62,0.4)])
c_sram_8b_16_1rw_tsmc65n_p_.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_c, (0,0.035)))
c_sram_8b_16_1rw_tsmc65n_p_.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_c, (0.32,0.035)))
c_sram_8b_16_1rw_tsmc65n_p_.add(gdstk.Label('G', (0.23,0.12), layer=17, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p_.add(gdstk.Label('S', (0.07,0.12), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p_.add(gdstk.Label('D', (0.39,0.12), layer=31, texttype=0))

c_sram_8b_16_1rw_tsmc65n_n_ = lib.new_cell('sram_8b_16_1rw_tsmc65N_nmos_m1_w0_160_sm1_dm1_da_p')
R(c_sram_8b_16_1rw_tsmc65n_n_, L2_0, [(-0.16,-0.16,0.62,0.32)])
R(c_sram_8b_16_1rw_tsmc65n_n_, active, [(0,0,0.46,0.16)])
R(c_sram_8b_16_1rw_tsmc65n_n_, L12_0, [(-0.16,-0.16,0.62,0.32)])
R(c_sram_8b_16_1rw_tsmc65n_n_, poly, [(0.2,-0.14,0.26,0.3), (0.2,-0.14,0.26,0.3)])
R(c_sram_8b_16_1rw_tsmc65n_n_, nimplant, [(-0.05,-0.05,0.51,0.21)])
R(c_sram_8b_16_1rw_tsmc65n_n_, metal1, [(0,-0.005,0.14,0.165), (0.32,-0.005,0.46,0.165)])
R(c_sram_8b_16_1rw_tsmc65n_n_, boundary, [(-0.16,-0.16,0.62,0.32)])
c_sram_8b_16_1rw_tsmc65n_n_.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c, (0,-0.005)))
c_sram_8b_16_1rw_tsmc65n_n_.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c, (0.32,-0.005)))
c_sram_8b_16_1rw_tsmc65n_n_.add(gdstk.Label('G', (0.23,0.08), layer=17, texttype=0))
c_sram_8b_16_1rw_tsmc65n_n_.add(gdstk.Label('S', (0.07,0.08), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_n_.add(gdstk.Label('D', (0.39,0.08), layer=31, texttype=0))

c_sram_8b_16_1rw_tsmc65n_p__ = lib.new_cell('sram_8b_16_1rw_tsmc65N_pinv')
R(c_sram_8b_16_1rw_tsmc65n_p__, L2_0, [(-0.16,-0.045,1.195,1.135)])
R(c_sram_8b_16_1rw_tsmc65n_p__, nwell, [(-0.16,1.135,1.195,2.48)])
R(c_sram_8b_16_1rw_tsmc65n_p__, L12_0, [(-0.16,-0.045,1.195,1.135), (-0.16,1.135,1.195,2.48)])
R(c_sram_8b_16_1rw_tsmc65n_p__, poly, [(0.36,0.5,0.42,1.78), (0.275,1.105,0.36,1.215)])
R(c_sram_8b_16_1rw_tsmc65n_p__, metal1, [(0,-0.045,1.035,0.045), (0.16,-0.045,0.3,0.195), (0.72,0,0.86,0.26), (0.505,0.195,0.595,2.125), (0.19,1.09,0.36,1.23), (0.55,1.115,0.64,1.205), (0.16,1.955,0.3,2.405), (0.72,2.05,0.86,2.36), (0,2.315,1.035,2.405)])
R(c_sram_8b_16_1rw_tsmc65n_p__, boundary, [(0,0,1.035,2.36), (0,0,1.035,2.36)])
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_p_, (0.16,1.92)))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_n_, (0.16,0.2)))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_, (0.72,1.965)))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c__, (0.72,0.175)))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c___, (0.19,1.09)))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Label('A', (0.275,1.16), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Label('Z', (0.595,1.16), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Label('gnd', (0.518,0), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_p__.add(gdstk.Label('vdd', (0.518,2.36), layer=31, texttype=0))

sram_8b_16_1rw_tsmc65n_w = lib.new_cell('sram_8b_16_1rw_tsmc65N_wordline_driver')
R(sram_8b_16_1rw_tsmc65n_w, metal1, [(0,-0.045,2.39,0.045), (0.305,0.555,0.475,0.695), (0.625,1.075,0.795,1.215), (1.055,1.115,1.145,1.205), (1.1,1.115,1.63,1.205), (1.905,1.115,1.995,1.205), (1.055,1.16,1.145,1.795), (0,2.315,2.39,2.405)])
R(sram_8b_16_1rw_tsmc65n_w, boundary, [(0,0,2.39,2.36)])
sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_p, (0,0)))
sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_p__, (1.355,0)))
sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('Z', (1.95,1.16), layer=31, texttype=0))
sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('A', (0.39,0.625), layer=31, texttype=0))
sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('B', (0.71,1.145), layer=31, texttype=0))
sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('gnd', (1.195,0), layer=31, texttype=0))
sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('vdd', (1.195,2.36), layer=31, texttype=0))

c_sram_8b_16_1rw_tsmc65n_c____ = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_17')
R(c_sram_8b_16_1rw_tsmc65n_c____, metal1, [(0,0.015,0.17,0.155)])
R(c_sram_8b_16_1rw_tsmc65n_c____, metal2, [(0.01,0,0.16,0.17)])
R(c_sram_8b_16_1rw_tsmc65n_c____, via1, [(0.04,0.04,0.13,0.13)])
R(c_sram_8b_16_1rw_tsmc65n_c____, boundary, [(0,0,0.17,0.17)])

c_sram_8b_16_1rw_tsmc65n_c_____ = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_18')
R(c_sram_8b_16_1rw_tsmc65n_c_____, metal2, [(0.01,0,0.17,0.18)])
R(c_sram_8b_16_1rw_tsmc65n_c_____, metal3, [(0,0.01,0.18,0.17)])
R(c_sram_8b_16_1rw_tsmc65n_c_____, via2, [(0.04,0.04,0.14,0.14)])
R(c_sram_8b_16_1rw_tsmc65n_c_____, boundary, [(0,0,0.18,0.18)])

c_sram_8b_16_1rw_tsmc65n_c______ = lib.new_cell('sram_8b_16_1rw_tsmc65N_contact_21')
R(c_sram_8b_16_1rw_tsmc65n_c______, metal3, [(0,0.01,0.18,0.17)])
R(c_sram_8b_16_1rw_tsmc65n_c______, metal4, [(0.01,0,0.17,0.18)])
R(c_sram_8b_16_1rw_tsmc65n_c______, via3, [(0.04,0.04,0.14,0.14)])
R(c_sram_8b_16_1rw_tsmc65n_c______, boundary, [(0,0,0.18,0.18)])

c_sram_8b_16_1rw_tsmc65n_w = lib.new_cell('sram_8b_16_1rw_tsmc65N_wordline_driver_array')
R(c_sram_8b_16_1rw_tsmc65n_w, metal1, [(0.865,0.555,1.035,0.695), (2.465,1.115,2.555,1.205), (2.465,3.515,2.555,3.605), (0.865,4.025,1.035,4.165), (0.865,5.275,1.035,5.415), (2.465,5.835,2.555,5.925), (2.465,8.235,2.555,8.325), (0.865,8.745,1.035,8.885), (0.865,9.995,1.035,10.135), (2.465,10.555,2.555,10.645), (2.465,12.955,2.555,13.045), (0.865,13.465,1.035,13.605), (0.865,14.715,1.035,14.855), (2.465,15.275,2.555,15.365), (2.465,17.675,2.555,17.765), (0.865,18.185,1.035,18.325), (0.865,19.435,1.035,19.575), (2.465,19.995,2.555,20.085), (2.465,22.395,2.555,22.485), (0.865,22.905,1.035,23.045), (0.865,24.155,1.035,24.295), (2.465,24.715,2.555,24.805), (2.465,27.115,2.555,27.205), (0.865,27.625,1.035,27.765), (0.865,28.875,1.035,29.015), (2.465,29.435,2.555,29.525), (2.465,31.835,2.555,31.925), (0.865,32.345,1.035,32.485), (0.865,33.595,1.035,33.735), (2.465,34.155,2.555,34.245), (2.465,36.555,2.555,36.645), (0.865,37.065,1.035,37.205)])
R(c_sram_8b_16_1rw_tsmc65n_w, metal2, [(0.48,-0.05,0.64,0.05), (1.22,0,1.32,37.76), (2.87,2.31,3.03,2.41), (2.87,2.31,3.03,2.41), (0.48,4.67,0.64,4.77), (0.48,4.67,0.64,4.77), (2.87,7.03,3.03,7.13), (2.87,7.03,3.03,7.13), (0.48,9.39,0.64,9.49), (0.48,9.39,0.64,9.49), (2.87,11.75,3.03,11.85), (2.87,11.75,3.03,11.85), (0.48,14.11,0.64,14.21), (0.48,14.11,0.64,14.21), (2.87,16.47,3.03,16.57), (2.87,16.47,3.03,16.57), (0.48,18.83,0.64,18.93), (0.48,18.83,0.64,18.93), (2.87,21.19,3.03,21.29), (2.87,21.19,3.03,21.29), (0.48,23.55,0.64,23.65), (0.48,23.55,0.64,23.65), (2.87,25.91,3.03,26.01), (2.87,25.91,3.03,26.01), (0.48,28.27,0.64,28.37), (0.48,28.27,0.64,28.37), (2.87,30.63,3.03,30.73), (2.87,30.63,3.03,30.73), (0.48,32.99,0.64,33.09), (0.48,32.99,0.64,33.09), (2.87,35.35,3.03,35.45), (2.87,35.35,3.03,35.45), (0.48,37.71,0.64,37.81)])
R(c_sram_8b_16_1rw_tsmc65n_w, metal3, [(0.51,-0.08,0.61,0.08), (2.9,2.28,3,2.44), (2.9,2.28,3,2.44), (0.51,4.64,0.61,4.8), (0.51,4.64,0.61,4.8), (2.9,7,3,7.16), (2.9,7,3,7.16), (0.51,9.36,0.61,9.52), (0.51,9.36,0.61,9.52), (2.9,11.72,3,11.88), (2.9,11.72,3,11.88), (0.51,14.08,0.61,14.24), (0.51,14.08,0.61,14.24), (2.9,16.44,3,16.6), (2.9,16.44,3,16.6), (0.51,18.8,0.61,18.96), (0.51,18.8,0.61,18.96), (2.9,21.16,3,21.32), (2.9,21.16,3,21.32), (0.51,23.52,0.61,23.68), (0.51,23.52,0.61,23.68), (2.9,25.88,3,26.04), (2.9,25.88,3,26.04), (0.51,28.24,0.61,28.4), (0.51,28.24,0.61,28.4), (2.9,30.6,3,30.76), (2.9,30.6,3,30.76), (0.51,32.96,0.61,33.12), (0.51,32.96,0.61,33.12), (2.9,35.32,3,35.48), (2.9,35.32,3,35.48), (0.51,37.68,0.61,37.84)])
R(c_sram_8b_16_1rw_tsmc65n_w, metal4, [(0.48,-0.135,0.64,37.895), (2.87,-0.09,3.03,37.85)])
R(c_sram_8b_16_1rw_tsmc65n_w, boundary, [(0,0,4.05,37.76)])
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,0)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,4.72), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,4.72)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,9.44), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,9.44)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,14.16), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,14.16)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,18.88), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,18.88)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,23.6), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,23.6)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,28.32), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,28.32)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,33.04), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,33.04)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(sram_8b_16_1rw_tsmc65n_w, (0.56,37.76), x_reflection=True))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,1.06)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,3.49)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,5.78)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,8.21)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,10.5)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,12.93)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,15.22)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,17.65)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,19.94)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,22.37)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,24.66)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,27.09)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,29.38)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,31.81)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,34.1)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (1.185,36.53)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,2.275)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,2.27)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,2.27)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,2.275)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,2.27)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,2.27)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,6.995)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,6.99)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,6.99)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,6.995)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,6.99)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,6.99)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,11.715)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,11.71)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,11.71)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,11.715)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,11.71)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,11.71)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,16.435)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,16.43)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,16.43)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,16.435)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,16.43)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,16.43)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,21.155)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,21.15)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,21.15)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,21.155)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,21.15)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,21.15)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,25.875)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,25.87)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,25.87)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,25.875)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,25.87)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,25.87)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,30.595)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,30.59)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,30.59)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,30.595)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,30.59)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,30.59)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,35.315)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,35.31)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,35.31)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (2.865,35.315)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (2.86,35.31)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (2.86,35.31)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,-0.085)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,-0.09)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,-0.09)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,4.635)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,4.63)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,4.63)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,4.635)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,4.63)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,4.63)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,9.355)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,9.35)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,9.35)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,9.355)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,9.35)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,9.35)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,14.075)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,14.07)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,14.07)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,14.075)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,14.07)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,14.07)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,18.795)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,18.79)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,18.79)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,18.795)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,18.79)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,18.79)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,23.515)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,23.51)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,23.51)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,23.515)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,23.51)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,23.51)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,28.235)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,28.23)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,28.23)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,28.235)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,28.23)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,28.23)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,32.955)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,32.95)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,32.95)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,32.955)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,32.95)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,32.95)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c____, (0.475,37.675)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c_____, (0.47,37.67)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Reference(c_sram_8b_16_1rw_tsmc65n_c______, (0.47,37.67)))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('en', (1.27,18.88), layer=32, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_0', (0.95,0.625), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_0', (2.51,1.16), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_1', (0.95,4.095), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_1', (2.51,3.56), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_2', (0.95,5.345), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_2', (2.51,5.88), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_3', (0.95,8.815), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_3', (2.51,8.28), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_4', (0.95,10.065), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_4', (2.51,10.6), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_5', (0.95,13.535), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_5', (2.51,13), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_6', (0.95,14.785), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_6', (2.51,15.32), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_7', (0.95,18.255), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_7', (2.51,17.72), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_8', (0.95,19.505), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_8', (2.51,20.04), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_9', (0.95,22.975), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_9', (2.51,22.44), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_10', (0.95,24.225), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_10', (2.51,24.76), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_11', (0.95,27.695), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_11', (2.51,27.16), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_12', (0.95,28.945), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_12', (2.51,29.48), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_13', (0.95,32.415), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_13', (2.51,31.88), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_14', (0.95,33.665), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_14', (2.51,34.2), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('in_15', (0.95,37.135), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('wl_15', (2.51,36.6), layer=31, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('vdd', (2.95,18.88), layer=34, texttype=0))
c_sram_8b_16_1rw_tsmc65n_w.add(gdstk.Label('gnd', (0.56,18.88), layer=34, texttype=0))

lib.write_gds('sram_8b_16_1rw_tsmc65N_wordline_driver_array.gds')
